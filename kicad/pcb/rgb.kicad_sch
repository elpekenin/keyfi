File: kicad/pcb/rgb.kicad_sch (KiCad schematic)
At the start: 58 parts

Commit message: USB (almost) done + some STM progress
Other:
- added sheet Caps (caps.kicad_sch)
